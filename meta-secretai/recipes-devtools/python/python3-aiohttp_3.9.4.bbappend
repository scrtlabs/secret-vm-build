# Enable the recipe to be built for native/nativesdk
BBCLASSEXTEND = "native nativesdk"
