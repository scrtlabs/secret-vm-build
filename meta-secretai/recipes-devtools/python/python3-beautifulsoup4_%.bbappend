# Add an RPROVIDES to satisfy python3-bs4 dependencies
RPROVIDES:${PN} += "python3-bs4"
