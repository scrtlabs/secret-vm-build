FILESEXTRAPATHS:append := "${THISDIR}/files:"

SRC_URI += "file://0001-keyslot-fix.patch"
